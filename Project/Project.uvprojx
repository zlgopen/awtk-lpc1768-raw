# Keil uVision project Project.uvprojx, settings and files
target 宝马3.2LCD test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1
  c define: HAS_AWTK_CONFIG
  c misc: --gnu
  c include: ..\Cmsis;..\ExtiDrive;..\Cmsis;..\BaseDrive\Lcd;..\BaseDrive\Picture;../awtk/src;../awtk/src/ext_widgets;../awtk/3rd;../awtk/3rd/agge;../awtk/3rd/nanovg;../awtk/3rd/nanovg/base;../awtk/3rd/gpinyin/include../awtk/3rd/libunibreak;../awtk-port
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Cmsis
    ../Cmsis/: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
  group App
    ../App/: main.c LPC17xx_it.c
  group BaseDrive/LCD
    ../BaseDrive/Lcd/: Lcd.c
  group awtk
    ../awtk/src/tkc/: buffer.c color.c color_parser.c compressor.c crc.c darray.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c expr_eval.c fs.c func_call_parser.c idle_info.c idle_manager.c int_str.c iostream.c istream.c matrix.c mem.c named_value.c object.c object_array.c object_default.c ostream.c path.c rect.c ring_buffer.c rom_fs.c slist.c socket_pair.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c utf8.c utils.c value.c value_desc.c wstr.c log.c asset_info.c
    ../awtk/src/base/: assets_manager.c bitmap.c canvas.c children_layouter.c children_layouter_factory.c clip_board.c dialog.c dialog_highlighter.c dialog_highlighter_factory.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c glyph_cache.c graphic_buffer.c hscrollable.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c lcd_profile.c line_break.c locale_info.c main_loop.c native_window.c self_layouter.c self_layouter_factory.c shortcut.c style.c style_const.c style_factory.c style_mutable.c suggest_words.c system_info.c text_edit.c theme.c timer.c ui_builder.c ui_feedback.c ui_loader.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window.c window_animator.c window_animator_factory.c window_base.c window_manager.c date_time_format.c asset_loader.c
    ../awtk/src/clip_board/: clip_board_default.c
    ../awtk/src/font_loader/: font_loader_bitmap.c
    ../awtk/src/graphic_buffer/: graphic_buffer_default.c
    ../awtk/src/input_engines/: input_engine_null.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/layouters/: children_layouter_builtins.c children_layouter_parser.c self_layouter_builtins.c self_layouter_default.c self_layouter_menu.c self_layouter_parser.c children_layouter_default.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/native_window/: native_window_raw.c
    ../awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/vgcanvas/: vgcanvas_null.c
    ../awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c color_tile.c column.c combo_box.c combo_box_item.c dialog_client.c dialog_helper.c dialog_title.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c overlay.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c widgets.c digit_clock.c clip_view.c
    ../awtk/src/window_manager/: window_manager_default.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
    ../awtk/src/: awtk_global.c
    ../awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
    ../awtk/src/blend/: blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c image_g2d.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c soft_g2d.c blend_image_rgb888_bgr565.c blend_image_rgb888_bgra8888.c blend_image_rgb888_rgba8888.c fill_image_rgb888.c rotate_image_rgb888.c blend_image_bgr565_rgb565.c blend_image_bgr888_rgb565.c blend_image_bgra8888_rgb565.c blend_image_rgb565_rgb565.c blend_image_rgb888_rgb565.c blend_image_rgba8888_rgb565.c blend_image_bgr888_bgr888.c blend_image_rgb888_rgb888.c
    ../awtk/src/platforms/raw/: cond_var_null.c fs_os.c mutex_null.c sys_tick_handler.c
  group awtk-port
    ../awtk-port/: assert.c platform.c lcd_impl.c main_loop_impl.c sys_tick.c
software components: CMSIS:CORE 4.1.0
